# Keil uVision project first.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Libraries\inc;..\Libraries\src;..\User;..\SYSTEM\INC;..\SYSTEM\MAINH;..\SYSTEM\IIC;..\SYSTEM\24CXX;..\SYSTEM\sys;..\SYSTEM\SLE4442;..\SYSTEM\ADC;..\SYSTEM\SRC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c
  group Libraries
    ../Libraries/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c misc.c
  group User
    ../User/: stm32f10x_it.c system_stm32f10x.c
    ./: main.c
  group SRC
    ../SYSTEM/SRC/: init.c time.c uart.c ysxxs.c display.c RX1_DataCl.c ads7843.c sound.c
  group MAIN
    ../SYSTEM/MAIN/: main_interface.c xs_check_fun.c xs_advanced_settings.c
